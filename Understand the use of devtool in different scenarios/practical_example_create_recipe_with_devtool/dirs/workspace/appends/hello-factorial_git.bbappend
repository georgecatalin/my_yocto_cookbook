inherit externalsrc
EXTERNALSRC = "/home/georgeca/yocto_tutorial/my_builds/workspace/sources/hello-factorial"
EXTERNALSRC_BUILD = "/home/georgeca/yocto_tutorial/my_builds/workspace/sources/hello-factorial"

# initial_rev: 27134a05d6b5aa06a474bc0002f6541550ac51e0
